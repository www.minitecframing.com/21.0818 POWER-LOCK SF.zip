# Autodesk Inventor assembly: 21.0818 POWER-LOCK SF
## iProperties
Created: 2009-01
Part Number: 21.0818 POWER-LOCK SF
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
